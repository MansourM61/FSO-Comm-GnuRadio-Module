<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>FSO_Comm_Demo</value></param>
<param><key>author</key><value>M Mansour Abadi</value></param>
<param><key>description</key><value>Modules from FSO_Comm are used in a simple FSO comunication link including various channel effects.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FSO Communication Block Modules Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>2.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Chunck_Size</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Cn2</value></param>
<param><key>value</key><value>5e-12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ext_Ratio</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gain</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P_0</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>P_n</value></param>
<param><key>value</key><value>1e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Resp</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rx_Dia</value></param>
<param><key>value</key><value>50e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sample_Offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>T_0</value></param>
<param><key>value</key><value>50e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Theta_0</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tx_Dia</value></param>
<param><key>value</key><value>3e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Z_0</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>jitter</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>link_len</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vis</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wavelength</value></param>
<param><key>value</key><value>850e-9</value></param>
</block>
<block>
<key>FSO_Comm_FogSmoke_Loss_ff</key>
<param><key>id</key><value>FSO_Comm_FogSmoke_Loss_ff_0</value></param>
<param><key>LinkLen</key><value>link_len</value></param>
<param><key>Vis</key><value>vis</value></param>
<param><key>Wavelen</key><value>wavelength</value></param>
</block>
<block>
<key>FSO_Comm_Geometric_Loss_ff</key>
<param><key>id</key><value>FSO_Comm_Geometric_Loss_ff_0</value></param>
<param><key>Tx_DivAng</key><value>Theta_0</value></param>
<param><key>LinkLen</key><value>link_len</value></param>
<param><key>Rx_Dia</key><value>Rx_Dia</value></param>
<param><key>Tx_Dia</key><value>Tx_Dia</value></param>
</block>
<block>
<key>FSO_Comm_Laser_ff</key>
<param><key>id</key><value>FSO_Comm_Laser_ff_0</value></param>
<param><key>P_avg</key><value>P_0</value></param>
<param><key>ExtRatio</key><value>Ext_Ratio</value></param>
<param><key>Wavelen</key><value>wavelength</value></param>
</block>
<block>
<key>FSO_Comm_Optical_Receiver_ff</key>
<param><key>id</key><value>FSO_Comm_Optical_Receiver_ff_0</value></param>
<param><key>P_n</key><value>P_n</value></param>
<param><key>Imp</key><value>Z_0</value></param>
<param><key>Resp</key><value>Resp</value></param>
<param><key>G_TIA</key><value>Gain</value></param>
</block>
<block>
<key>FSO_Comm_Pointing_Errors_ff</key>
<param><key>id</key><value>FSO_Comm_Pointing_Errors_ff_0</value></param>
<param><key>TempCorr</key><value>T_0</value></param>
<param><key>LinkLen</key><value>link_len</value></param>
<param><key>Jitter</key><value>jitter</value></param>
<param><key>Rx_Dia</key><value>Rx_Dia</value></param>
<param><key>SampRate</key><value>samp_rate</value></param>
<param><key>Tx_Dia</key><value>Tx_Dia</value></param>
<param><key>Tx_Theta</key><value>Theta_0</value></param>
</block>
<block>
<key>FSO_Comm_Turbulence_ff</key>
<param><key>id</key><value>FSO_Comm_Turbulence_ff_0</value></param>
<param><key>TempCorr</key><value>T_0</value></param>
<param><key>LinkLen</key><value>link_len</value></param>
<param><key>Rx_Dia</key><value>Rx_Dia</value></param>
<param><key>SampRate</key><value>samp_rate</value></param>
<param><key>Cn2</key><value>Cn2</value></param>
<param><key>Wavelen</key><value>wavelength</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2.5e-3</value></param>
<param><key>ymin</key><value>-0.1e-3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>After_Turb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>After_Turb</value></param>
</block>
<connection><source_block_id>FSO_Comm_FogSmoke_Loss_ff_0</source_block_id><sink_block_id>FSO_Comm_Optical_Receiver_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FSO_Comm_Geometric_Loss_ff_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FSO_Comm_Laser_ff_0</source_block_id><sink_block_id>FSO_Comm_Geometric_Loss_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FSO_Comm_Optical_Receiver_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FSO_Comm_Pointing_Errors_ff_0</source_block_id><sink_block_id>FSO_Comm_FogSmoke_Loss_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>FSO_Comm_Turbulence_ff_0</source_block_id><sink_block_id>FSO_Comm_Pointing_Errors_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>FSO_Comm_Laser_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>FSO_Comm_Turbulence_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
